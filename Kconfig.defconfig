## Kconfig.defconfig
```kconfig
CONFIG_BUILD_OUTPUT_UF2=y
if VideoWriterBT

config ZMK_KEYBOARD_NAME
    default "VideoWriterBT"

endif
```
